## numato-driver/xdma_driver_wait/Kconfig
```kconfig
config MYCRYPTO
	tristate "emxample"
	help
		This is a exmaple, for develop kernel module
		If you does not sure, say N.
```
